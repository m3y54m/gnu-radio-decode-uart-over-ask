options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: UART over OOK Decoder
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samples_per_bit
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: int(samp_rate / baud_rate / samples_per_bit)
  states: {}
- name: time_sink_total_points
  id: variable
  parameters:
    value: '120000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: bitstream.bin
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samples_per_symbol
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.75'
    init: '0'
    low: '0.25'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samples_per_bit=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Decode UART Bitstream',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samples_per_bit = samples_per_bit
              self.sample_index = 0
              self.sample_sum = 0
              
              self.uart_start_bit_detected = False
              self.uart_data_byte = 0
              self.uart_data_bit_index = 0

              self.last_bit_value = 0

          def work(self, input_items, output_items):
          
              """
              | START | D0 | D1 | D2 | D3 | D4 | D5 | D6 | D7 | STOP |
              """

              # Get input bytes    
              # Iterarte over stream of bytes in input_items[0]
              for byte_value in input_items[0]:

                  # Iterate over the bits of current byte value
                  for bit_index in range(8):
                      # extract the bit values from the MSB (left) side of the byte
                      bit_value = (byte_value >> (7 - bit_index)) & 0x01

                      # Sum of values of total samples for current bit
                      self.sample_sum += bit_value
                      # Index of samples for current bit
                      self.sample_index += 1

                      if self.sample_index >= self.samples_per_bit:
                          # Calculate the current bit value according to the sum of samples and the 1/0 threshold
                          if self.sample_sum >= (self.samples_per_bit // 2 + 1):
                              current_bit_value = 1
                          else:
                              current_bit_value = 0

                          self.sample_index = 0
                          self.sample_sum = 0

                          if not self.uart_start_bit_detected:
                              # Check the START bit in the falling edge of signal
                              if current_bit_value == 0 and self.last_bit_value == 1:
                                  self.uart_start_bit_detected = True
                                  self.uart_data_bit_index = 0
                                  self.uart_data_byte = 0
                          else:
                              # Get bits of the DATA byte
                              if self.uart_data_bit_index < 8:
                                  self.uart_data_byte = self.uart_data_byte | (
                                      current_bit_value << self.uart_data_bit_index
                                  )
                                  self.uart_data_bit_index += 1
                              else:
                                  # Check the STOP bit
                                  # if STOP bit is not equal to '1' this is a corrupt frame
                                  if current_bit_value == 0:
                                      print("corrupt byte!")
                                  else:
                                      # UART frame is healthy
                                      # Output the data byte
                                      output_items[0][:] = self.uart_data_byte
                                      print(self.uart_data_byte)

                                  self.uart_start_bit_detected = False

                          self.last_bit_value = current_bit_value
                                  
              return len(output_items[0])
    samples_per_bit: samples_per_bit
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Demodulated Signal"'
    size: time_sink_total_points
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Synchronized UART Signal"'
    size: int(time_sink_total_points / samples_per_symbol)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Input Modulated Signal"'
    size: time_sink_total_points
    srate: samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433.988e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_throttle2_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
